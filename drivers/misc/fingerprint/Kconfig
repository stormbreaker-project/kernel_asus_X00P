## drivers/misc/fingerprint/Kconfig
```kconfig
source "drivers/misc/fingerprint/leadcore/Kconfig"
source "drivers/misc/fingerprint/sunwave/Kconfig"
```
